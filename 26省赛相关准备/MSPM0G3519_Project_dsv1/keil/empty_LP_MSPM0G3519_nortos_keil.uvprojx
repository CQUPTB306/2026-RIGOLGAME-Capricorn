# Keil uVision project empty_LP_MSPM0G3519_nortos_keil.uvprojx, settings and files
target MSPM0G3519_Project (6180000::V6.18::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  pack: TexasInstruments.MSPM0GX51X_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00080000) IROM2(0x00400000,0x00080000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3519_nortos_keil +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ..;..\BSP;..\hard;C:\ti\mspm0_sdk_2_10_00_04\source;C:\ti\mspm0_sdk_2_10_00_04\source\ti\devices\msp\m0p;C:\ti\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3519.sct
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c board.c
    ./: startup_mspm0g351x_uvision.s
    ../hard/: motor.c pca9685.c soft_i2c_simple.c track.c oled.c soft_i2c_track.c track_gpio.c track_gpio.h encoder.c st7735_tft.c
  group Driverlib
    ../ti/: dl_vref.c dl_uart.c dl_trng.c dl_timer.c dl_spi.c dl_rtc_common.c dl_opa.c dl_mcan.c dl_mathacl.c dl_lfss.c dl_lcd.c dl_keystorectl.c dl_i2c.c dl_flashctl.c dl_factoryregion.c dl_sysctl_mspm0gx51x.c dl_dma.c dl_dac12.c dl_crcp.c dl_crc.c dl_common.c dl_aesadv.c dl_aes.c dl_adc12.c
